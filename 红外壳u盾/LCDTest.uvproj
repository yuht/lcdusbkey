# Keil uVision project LCDTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K60S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LCDTest +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source
    ./Source/: main.c JLX_LCD_v2.0.c
